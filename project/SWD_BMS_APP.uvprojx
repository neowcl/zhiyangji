# Keil uVision project SWD_BMS_APP.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: CBM8580_v2 Chipsea
  pack: Chipsea.CBM858x_v2_DFP.1.0.3
  cpu: IRAM(0x20000000,0x6000?) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: APP
  AfterMake: fromelf.exe --bin --bincombined --bincombined_padding=1,0xff --output @L.bin !L
  AfterMake: CBM8580_bin.exe
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELEASE_MODE
  c include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x32000
  memory RVCT9: RAM 0x200000c0 size 0x10000
  group app
    ../APP/src/: AdvancedChargeAlgorithm.c afe_cvt.c afetimer.c Calc_Attf.c cbm8580m_int.c comm_protocol.c data_flash_value.c dataflash.c datcalc_spl.c hdp.c lifetime.c log.c lptm.c main.c mcu.c mode.c modules_sha1.c oscm.c Power_Modes.c protect.c ra_value.c ram.c rtc.c SBS_Commands.c smbus_protocol.c soft_timer.c tim.c UpFlash.c
software components: CMSIS:CORE 5.4.0, Device:Driver:AFE 1.0.0, Device:Driver:CRYPTO 1.0.0, Device:Driver:Framework 1.0.3, Device:Startup 1.0.0
